# Keil uVision project STM32F205_Keyboard_FreeRTOS_Test.uvprojx, settings and files
target STM32F205_Keyboard_FreeRTOS_Test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F205RBTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2000BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x801FFFF)  CLOCK(25000000) CPUTYPE("Cortex-M3") TZ
  output: STM32F205_Keyboard_FreeRTOS_Test +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=..\FIRMWARE\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F205xx,CO_ENABLE_LSS, DEBUG_ERR_CONSOLE_ON
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F2xx_HAL_Driver/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../Drivers/CMSIS/Include;../CAN_Festival/include;../CAN_Festival/include/STM32;../Dictionary
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f205xx.s
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_pcd.c stm32f2xx_ll_usb.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c stm32f2xx_hal_can.c stm32f2xx_hal_i2c.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f2xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Inc
    ../Core/Inc/: can.h can_festival_save_param.h CanOpen_Callbacks.h eeprom.h FreeRTOSConfig.h gpio.h i2c.h Keyboard.h main.h ParamDataFlash.h print_ch.h stm32f2xx_hal_conf.h stm32f2xx_it.h storage.h tim.h timer_STM32.h HT.h
  group Src
    ../Core/Src/: can.c can_festival_save_param.c can_STM32.c CanOpen_Callbacks.c eeprom.c freertos.c gpio.c i2c.c Keyboard.c main.c ParamDataFlash.c print_ch.c stm32f2xx_hal_msp.c stm32f2xx_hal_timebase_tim.c stm32f2xx_it.c storage.c tim.c timer_STM32.c HT_Proc.c
  group CAN_Festival
    ../CAN_Festival/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group Dictionary
    ../Dictionary/: Keyboard_dict.c
software components: CMSIS:CORE 4.3.0
